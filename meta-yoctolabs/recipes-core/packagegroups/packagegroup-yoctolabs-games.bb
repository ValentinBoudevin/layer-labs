SUMMARY = "Trusted Services test/demo linux tools"

inherit packagegroup

RDEPENDS:${PN} = " ninvaders"